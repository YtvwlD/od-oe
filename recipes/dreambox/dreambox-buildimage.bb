require dreambox-buildimage.inc

inherit autotools


require sqlite3.inc
CFLAGS_opendreambox += "-DSQLITE_ENABLE_COLUMN_METADATA"
